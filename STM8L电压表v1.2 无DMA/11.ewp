# IAR project 11.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc; USER\TIME; USER\OLED; USER\SI7021; USER\crc; USER\FLASH; USER\ADC; USER\KEY; G:\文件备份\代码-STM8\STM8L电压表\USER\UART
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 11.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: 11.out
  group (top)
    ./: IOSTM8L051F3.h main.c stm8l15x_it.c
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_usart.c
  group USER
    USER/ADC/: ADC.c
    USER/KEY/: KEY.c
    USER/OLED/: oled.c oledfont.h
    USER/UART/: StringTool.c
    USER/TIME/: TIM.c
